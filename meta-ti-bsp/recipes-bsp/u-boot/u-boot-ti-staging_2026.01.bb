require u-boot-ti.inc

PR = "r0"

BRANCH = "ti-u-boot-2026.01"

SRCREV_uboot = "0bc4da985e79227ee031bc5cab5a16ff0da9f349"
